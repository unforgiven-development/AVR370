# IAR project mega_1284p_xplained_example.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0xFF
  General.SCRStackSize: 0x28
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _QTOUCH_; QT_NUM_CHANNELS=4; QTOUCH_STUDIO_MASKS=1; _DEBUG_INTERFACE_; SNS1=D; SNSK1=D; QT_DELAY_CYCLES=1; _SNS1_SNSK1_SAME_PORT_
  ICCAVR.newCCIncludePaths: ..\..\..\common_files; ..\..\..\..\..\include; ..\..\..\..\..\debug; $PROJ_DIR$..\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1284p.xcl
  group (top)
    ../: avr_compiler.h init.c init.h libv3g2-4qt-k-0rs.r90 mega_1284p_xplained_example.c qt_asm_tiny_mega.S touch_api.h touch_qt_config.h usart.c usart.h
